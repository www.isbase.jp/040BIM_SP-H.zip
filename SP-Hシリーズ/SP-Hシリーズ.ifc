Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [ContentGUID: 0bf2b43a-6102-4418-b428-4da8559a771d, VersionGUID: abcd832b-0359-4e12-a6f0-14fb70ad8c4e, NumberOfSaves: 10], CoordinateReference [CoordinateBase: 共有座標], ExchangeRequirement [Structural]
File name: SP-Hシリーズ.ifc
Time: 2025-11-05T18:40:14+09:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.4.30.30 (JPN) - IFC 25.4.30.30

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: プロジェクト情報

# IfcBuilding
Pset_BuildingCommon - Reference: プロジェクト情報; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: プロジェクト情報; IsExternal: no
Pset_BuildingStoreyCommon - Reference: プロジェクト情報; sets with these values: 2

# IfcBuildingStorey: レベル:レベル 1, レベル 1
LongName: レベル 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: レベル 1

# IfcBuildingElementProxy: ISベース_SP:SP151H, ISベース_SP:SP151H:4553
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SP151H; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: SP151H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.37792 m2; NetVolume: 0.00847401 m3

# IfcBuildingElementProxy: ISベース_SP:SP152H, ISベース_SP:SP152H:4572
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP152H
Pset_EnvironmentalImpactIndicators - Reference: SP152H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.46282 m2; NetVolume: 0.00992243 m3

# IfcBuildingElementProxy: ISベース_SP:SP171H, ISベース_SP:SP171H:6915
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP171H
Pset_EnvironmentalImpactIndicators - Reference: SP171H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.49914 m2; NetVolume: 0.00966535 m3

# IfcBuildingElementProxy: ISベース_SP:SP172H, ISベース_SP:SP172H:6916
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP172H
Pset_EnvironmentalImpactIndicators - Reference: SP172H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.61625 m2; NetVolume: 0.0122854 m3

# IfcBuildingElementProxy: ISベース_SP:SP201H, ISベース_SP:SP201H:6935
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP201H
Pset_EnvironmentalImpactIndicators - Reference: SP201H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.61865 m2; NetVolume: 0.011818 m3

# IfcBuildingElementProxy: ISベース_SP:SP202H, ISベース_SP:SP202H:6936
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP202H
Pset_EnvironmentalImpactIndicators - Reference: SP202H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.74665 m2; NetVolume: 0.0144481 m3

# IfcBuildingElementProxy: ISベース_SP:SP203H, ISベース_SP:SP203H:16723
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP203H
Pset_EnvironmentalImpactIndicators - Reference: SP203H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.74096 m2; NetVolume: 0.0151998 m3

# IfcBuildingElementProxy: ISベース_SP:SP251H, ISベース_SP:SP251H:6944
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP251H
Pset_EnvironmentalImpactIndicators - Reference: SP251H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.82265 m2; NetVolume: 0.0137358 m3

# IfcBuildingElementProxy: ISベース_SP:SP252H, ISベース_SP:SP252H:6945
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP252H
Pset_EnvironmentalImpactIndicators - Reference: SP252H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.05065 m2; NetVolume: 0.0180085 m3

# IfcBuildingElementProxy: ISベース_SP:SP253H, ISベース_SP:SP253H:7153
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP253H
Pset_EnvironmentalImpactIndicators - Reference: SP253H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.04456 m2; NetVolume: 0.0188481 m3

# IfcBuildingElementProxy: ISベース_SP:SP254H, ISベース_SP:SP254H:7161
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP254H
Pset_EnvironmentalImpactIndicators - Reference: SP254H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.43083 m2; NetVolume: 0.0235425 m3

# IfcBuildingElementProxy: ISベース_SP:SP301H, ISベース_SP:SP301H:6957
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP301H
Pset_EnvironmentalImpactIndicators - Reference: SP301H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.14384 m2; NetVolume: 0.0199971 m3

# IfcBuildingElementProxy: ISベース_SP:SP302H, ISベース_SP:SP302H:6958
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP302H
Pset_EnvironmentalImpactIndicators - Reference: SP302H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.52443 m2; NetVolume: 0.0238556 m3

# IfcBuildingElementProxy: ISベース_SP:SP303H, ISベース_SP:SP303H:7178
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP303H
Pset_EnvironmentalImpactIndicators - Reference: SP303H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.68333 m2; NetVolume: 0.0277556 m3

# IfcBuildingElementProxy: ISベース_SP:SP304H, ISベース_SP:SP304H:7186
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP304H
Pset_EnvironmentalImpactIndicators - Reference: SP304H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.90513 m2; NetVolume: 0.0328212 m3

# IfcBuildingElementProxy: ISベース_SP:SP305H, ISベース_SP:SP305H:7194
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP305H
Pset_EnvironmentalImpactIndicators - Reference: SP305H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.09593 m2; NetVolume: 0.0375689 m3

# IfcBuildingElementProxy: ISベース_SP:SP351H, ISベース_SP:SP351H:6966
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP351H
Pset_EnvironmentalImpactIndicators - Reference: SP351H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.84873 m2; NetVolume: 0.0288023 m3

# IfcBuildingElementProxy: ISベース_SP:SP352H, ISベース_SP:SP352H:6967
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP352H
Pset_EnvironmentalImpactIndicators - Reference: SP352H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.21513 m2; NetVolume: 0.0378365 m3

# IfcBuildingElementProxy: ISベース_SP:SP353H, ISベース_SP:SP353H:7214
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP353H
Pset_EnvironmentalImpactIndicators - Reference: SP353H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.25927 m2; NetVolume: 0.0389626 m3

# IfcBuildingElementProxy: ISベース_SP:SP354H, ISベース_SP:SP354H:7215
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP354H
Pset_EnvironmentalImpactIndicators - Reference: SP354H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.56127 m2; NetVolume: 0.047843 m3

# IfcBuildingElementProxy: ISベース_SP:SP355H, ISベース_SP:SP355H:7216
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP355H
Pset_EnvironmentalImpactIndicators - Reference: SP355H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.83307 m2; NetVolume: 0.0554726 m3

# IfcBuildingElementProxy: ISベース_SP:SP401H, ISベース_SP:SP401H:6975
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP401H
Pset_EnvironmentalImpactIndicators - Reference: SP401H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.40093 m2; NetVolume: 0.0389343 m3

# IfcBuildingElementProxy: ISベース_SP:SP402H, ISベース_SP:SP402H:6976
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP402H
Pset_EnvironmentalImpactIndicators - Reference: SP402H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.57719 m2; NetVolume: 0.0436663 m3

# IfcBuildingElementProxy: ISベース_SP:SP403H, ISベース_SP:SP403H:7234
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP403H
Pset_EnvironmentalImpactIndicators - Reference: SP403H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.01119 m2; NetVolume: 0.0559721 m3

# IfcBuildingElementProxy: ISベース_SP:SP404H, ISベース_SP:SP404H:7235
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP404H
Pset_EnvironmentalImpactIndicators - Reference: SP404H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.40239 m2; NetVolume: 0.0690613 m3

# IfcBuildingElementProxy: ISベース_SP:SP405H, ISベース_SP:SP405H:7236
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP405H
Pset_EnvironmentalImpactIndicators - Reference: SP405H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.53992 m2; NetVolume: 0.065047 m3

# IfcBuildingElementProxy: ISベース_SP:SP406H, ISベース_SP:SP406H:7248
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP406H
Pset_EnvironmentalImpactIndicators - Reference: SP406H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.41712 m2; NetVolume: 0.0679381 m3

# IfcBuildingElementProxy: ISベース_SP:SP451H, ISベース_SP:SP451H:6984
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP451H
Pset_EnvironmentalImpactIndicators - Reference: SP451H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.95793 m2; NetVolume: 0.0502513 m3

# IfcBuildingElementProxy: ISベース_SP:SP452H, ISベース_SP:SP452H:6985
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP452H
Pset_EnvironmentalImpactIndicators - Reference: SP452H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.22239 m2; NetVolume: 0.0572693 m3

# IfcBuildingElementProxy: ISベース_SP:SP453H, ISベース_SP:SP453H:7268
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP453H
Pset_EnvironmentalImpactIndicators - Reference: SP453H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.93799 m2; NetVolume: 0.0807521 m3

# IfcBuildingElementProxy: ISベース_SP:SP454H, ISベース_SP:SP454H:7274
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP454H
Pset_EnvironmentalImpactIndicators - Reference: SP454H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.06912 m2; NetVolume: 0.0762229 m3

# IfcBuildingElementProxy: ISベース_SP:SP455H, ISベース_SP:SP455H:7282
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP455H
Pset_EnvironmentalImpactIndicators - Reference: SP455H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.61512 m2; NetVolume: 0.092138 m3

# IfcBuildingElementProxy: ISベース_SP:SP456H, ISベース_SP:SP456H:7288
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP456H
Pset_EnvironmentalImpactIndicators - Reference: SP456H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.05232 m2; NetVolume: 0.0812932 m3

# IfcBuildingElementProxy: ISベース_SP:SP457H, ISベース_SP:SP457H:7296
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP457H
Pset_EnvironmentalImpactIndicators - Reference: SP457H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.23761 m2; NetVolume: 0.0871298 m3

# IfcBuildingElementProxy: ISベース_SP:SP501H, ISベース_SP:SP501H:6993
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP501H
Pset_EnvironmentalImpactIndicators - Reference: SP501H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.14199 m2; NetVolume: 0.0531493 m3

# IfcBuildingElementProxy: ISベース_SP:SP502H, ISベース_SP:SP502H:6994
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP502H
Pset_EnvironmentalImpactIndicators - Reference: SP502H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.89832 m2; NetVolume: 0.0667339 m3

# IfcBuildingElementProxy: ISベース_SP:SP503H, ISベース_SP:SP503H:7317
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP503H
Pset_EnvironmentalImpactIndicators - Reference: SP503H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.66735 m2; NetVolume: 0.0644437 m3

# IfcBuildingElementProxy: ISベース_SP:SP504H, ISベース_SP:SP504H:7318
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP504H
Pset_EnvironmentalImpactIndicators - Reference: SP504H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.51252 m2; NetVolume: 0.0827301 m3

# IfcBuildingElementProxy: ISベース_SP:SP505H, ISベース_SP:SP505H:7319
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP505H
Pset_EnvironmentalImpactIndicators - Reference: SP505H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.35275 m2; NetVolume: 0.0882125 m3

# IfcBuildingElementProxy: ISベース_SP:SP506H, ISベース_SP:SP506H:7320
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP506H
Pset_EnvironmentalImpactIndicators - Reference: SP506H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.39481 m2; NetVolume: 0.0870275 m3

# IfcBuildingElementProxy: ISベース_SP:SP507H, ISベース_SP:SP507H:7321
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP507H
Pset_EnvironmentalImpactIndicators - Reference: SP507H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.74761 m2; NetVolume: 0.0986232 m3

# IfcBuildingElementProxy: ISベース_SP:SP508H, ISベース_SP:SP508H:7334
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP508H
Pset_EnvironmentalImpactIndicators - Reference: SP508H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.94422 m2; NetVolume: 0.103625 m3

# IfcBuildingElementProxy: ISベース_SP:SP551H, ISベース_SP:SP551H:7002
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP551H
Pset_EnvironmentalImpactIndicators - Reference: SP551H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.91899 m2; NetVolume: 0.0700048 m3

# IfcBuildingElementProxy: ISベース_SP:SP552H, ISベース_SP:SP552H:7003
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP552H
Pset_EnvironmentalImpactIndicators - Reference: SP552H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.70412 m2; NetVolume: 0.0862349 m3

# IfcBuildingElementProxy: ISベース_SP:SP553H, ISベース_SP:SP553H:7358
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP553H
Pset_EnvironmentalImpactIndicators - Reference: SP553H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.52175 m2; NetVolume: 0.0878103 m3

# IfcBuildingElementProxy: ISベース_SP:SP554H, ISベース_SP:SP554H:7359
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP554H
Pset_EnvironmentalImpactIndicators - Reference: SP554H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.55441 m2; NetVolume: 0.0866532 m3

# IfcBuildingElementProxy: ISベース_SP:SP555H, ISベース_SP:SP555H:7360
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP555H
Pset_EnvironmentalImpactIndicators - Reference: SP555H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.20261 m2; NetVolume: 0.108801 m3

# IfcBuildingElementProxy: ISベース_SP:SP556H, ISベース_SP:SP556H:7361
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP556H
Pset_EnvironmentalImpactIndicators - Reference: SP556H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.47209 m2; NetVolume: 0.118222 m3

# IfcBuildingElementProxy: ISベース_SP:SP557H, ISベース_SP:SP557H:7362
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP557H
Pset_EnvironmentalImpactIndicators - Reference: SP557H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.57963 m2; NetVolume: 0.116854 m3

# IfcBuildingElementProxy: ISベース_SP:SP601H, ISベース_SP:SP601H:7011
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP601H
Pset_EnvironmentalImpactIndicators - Reference: SP601H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.75305 m2; NetVolume: 0.0611877 m3

# IfcBuildingElementProxy: ISベース_SP:SP602H, ISベース_SP:SP602H:7012
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP602H
Pset_EnvironmentalImpactIndicators - Reference: SP602H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.49251 m2; NetVolume: 0.0783984 m3

# IfcBuildingElementProxy: ISベース_SP:SP603H, ISベース_SP:SP603H:7386
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP603H
Pset_EnvironmentalImpactIndicators - Reference: SP603H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.90241 m2; NetVolume: 0.0938314 m3

# IfcBuildingElementProxy: ISベース_SP:SP604H, ISベース_SP:SP604H:7387
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP604H
Pset_EnvironmentalImpactIndicators - Reference: SP604H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.36942 m2; NetVolume: 0.104888 m3

# IfcBuildingElementProxy: ISベース_SP:SP605H, ISベース_SP:SP605H:7388
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP605H
Pset_EnvironmentalImpactIndicators - Reference: SP605H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.26222 m2; NetVolume: 0.140364 m3

# IfcBuildingElementProxy: ISベース_SP:SP606H, ISベース_SP:SP606H:7389
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP606H
Pset_EnvironmentalImpactIndicators - Reference: SP606H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.36803 m2; NetVolume: 0.151919 m3

# IfcBuildingElementProxy: ISベース_SP:SP651H, ISベース_SP:SP651H:7020
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP651H
Pset_EnvironmentalImpactIndicators - Reference: SP651H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.59259 m2; NetVolume: 0.0824813 m3

# IfcBuildingElementProxy: ISベース_SP:SP652H, ISベース_SP:SP652H:7021
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP652H
Pset_EnvironmentalImpactIndicators - Reference: SP652H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.22264 m2; NetVolume: 0.0949649 m3

# IfcBuildingElementProxy: ISベース_SP:SP653H, ISベース_SP:SP653H:7413
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP653H
Pset_EnvironmentalImpactIndicators - Reference: SP653H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.52969 m2; NetVolume: 0.105525 m3

# IfcBuildingElementProxy: ISベース_SP:SP654H, ISベース_SP:SP654H:7414
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP654H
Pset_EnvironmentalImpactIndicators - Reference: SP654H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.83542 m2; NetVolume: 0.115071 m3

# IfcBuildingElementProxy: ISベース_SP:SP655H, ISベース_SP:SP655H:7415
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP655H
Pset_EnvironmentalImpactIndicators - Reference: SP655H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 8.03494 m2; NetVolume: 0.156345 m3

# IfcBuildingElementProxy: ISベース_SP:SP656H, ISベース_SP:SP656H:7416
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP656H
Pset_EnvironmentalImpactIndicators - Reference: SP656H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.97083 m2; NetVolume: 0.168526 m3

# IfcBuildingElementProxy: ISベース_SP:SP701H, ISベース_SP:SP701H:7029
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP701H
Pset_EnvironmentalImpactIndicators - Reference: SP701H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.38251 m2; NetVolume: 0.095014 m3

# IfcBuildingElementProxy: ISベース_SP:SP702H, ISベース_SP:SP702H:7030
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP702H
Pset_EnvironmentalImpactIndicators - Reference: SP702H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.82841 m2; NetVolume: 0.113107 m3

# IfcBuildingElementProxy: ISベース_SP:SP703H, ISベース_SP:SP703H:7442
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP703H
Pset_EnvironmentalImpactIndicators - Reference: SP703H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.32142 m2; NetVolume: 0.125754 m3

# IfcBuildingElementProxy: ISベース_SP:SP704H, ISベース_SP:SP704H:7443
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP704H
Pset_EnvironmentalImpactIndicators - Reference: SP704H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 8.29222 m2; NetVolume: 0.166359 m3

# IfcBuildingElementProxy: ISベース_SP:SP705H, ISベース_SP:SP705H:16735
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP705H
Pset_EnvironmentalImpactIndicators - Reference: SP705H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 8.58164 m2; NetVolume: 0.176645 m3

# IfcBuildingElementProxy: ISベース_SP:SP751H, ISベース_SP:SP751H:7038
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP751H
Pset_EnvironmentalImpactIndicators - Reference: SP751H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.66801 m2; NetVolume: 0.1266 m3

# IfcBuildingElementProxy: ISベース_SP:SP752H, ISベース_SP:SP752H:7039
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP752H
Pset_EnvironmentalImpactIndicators - Reference: SP752H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 8.13083 m2; NetVolume: 0.14196 m3

# IfcBuildingElementProxy: ISベース_SP:SP753H, ISベース_SP:SP753H:7451
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP753H
Pset_EnvironmentalImpactIndicators - Reference: SP753H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 9.11294 m2; NetVolume: 0.18372 m3

# IfcBuildingElementProxy: ISベース_SP:SP754H, ISベース_SP:SP754H:7452
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP754H
Pset_EnvironmentalImpactIndicators - Reference: SP754H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 9.50524 m2; NetVolume: 0.215829 m3

# IfcBuildingElementProxy: ISベース_SP:SP801H, ISベース_SP:SP801H:7047
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP801H
Pset_EnvironmentalImpactIndicators - Reference: SP801H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 8.51774 m2; NetVolume: 0.149279 m3

# IfcBuildingElementProxy: ISベース_SP:SP802H, ISベース_SP:SP802H:7048
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP802H
Pset_EnvironmentalImpactIndicators - Reference: SP802H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 8.87724 m2; NetVolume: 0.163829 m3

# IfcBuildingElementProxy: ISベース_SP:SP803H, ISベース_SP:SP803H:7460
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP803H
Pset_EnvironmentalImpactIndicators - Reference: SP803H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 9.62103 m2; NetVolume: 0.198043 m3

# IfcBuildingElementProxy: ISベース_SP:SP804H, ISベース_SP:SP804H:7461
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SP804H
Pset_EnvironmentalImpactIndicators - Reference: SP804H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 10.0892 m2; NetVolume: 0.232637 m3
